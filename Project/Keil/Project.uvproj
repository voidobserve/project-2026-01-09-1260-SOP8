# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\Hardware
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group User
    ../../User/: main.c uart_data_handle.c
    ../../Libraries/Source/: debug.c
  group Hardware
    ../../Hardware/: adc.c timer.c task.c pwm.c key.c uart.c motor_handle.c
